	AREA RESET, CODE
	ENTRY
	LDR R0, =ARRAY
	LDMIA R0, {R1-R10} ;COPY FROM FLASH TO SRAM,USING REGISTERS
	MOV SP, #0X40000000
	STMIA SP, {R1-R10}
	MOV R10, #0X40000000 ; STARTING MEMORY ADDRESS OF ARRAY
	MOV R1, #10 ; TOTAL ELEMENTS
	SUB R1,#1 ; TOTAL ITERATIONS = N-1
LOOP1
	MOV R2, R1 ; NO OF COMPARISIONS IN A GIVEN PASS = NO OF PASSES LEFT
	MOV R4, R10 ; SET R4 = STARTING MEM ADDRESS,FOR EVERY PASS
LOOP2
	LDR R0, [R4] ; GET FIRST ELEMENT, ARR[i]
	LDR R5, [R4, #4] ;GET NEXT ELEMENT,ARR[i+1]
	CMP R0, R5
	BLS SKIP ;IF ARR[i]&lt;ARR[i+1], skip
	MOV R6, R0 ;else, SWAP ARR[i] &amp; ARR[i+1]
	MOV R0, R5
	MOV R5, R6
	STR R0, [R4]
	STR R5, [R4,#4]
SKIP
	ADD R4, #4
	SUBS R2, #1 ; GO TO NEXT COMPARISION
	BNE LOOP2
	SUBS R1, #1 ; GO TO NEXT ITERATION
	BNE LOOP1
STOP B STOP
ARRAY DCD 2,7,4,5,11,18,3,15,8,0
	END