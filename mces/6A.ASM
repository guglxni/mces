	AREA RESET,CODE
	ENTRY
	LDR R0,=INPUT
	BL FACT
	LDR R1,=0X40000000
	STR R3,[R1]
	
FACT
	LDR R2,[R0]
	CMP R2,#0
	BEQ EXIT
	MOV R3,R2
LOOP	
	SUB R2,#1
	CMP R2,#0
	BEQ EXIT2
	MUL R3,R2,R3
	B LOOP
	MOV PC,LR
EXIT
	MOV R3,#1
	MOV PC,LR
EXIT2
	MOV PC,LR

INPUT DCD &05
	END